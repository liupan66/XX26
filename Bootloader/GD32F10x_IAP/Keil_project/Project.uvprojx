# Keil uVision project Project.uvprojx, settings and files
target GD32F10X_CL (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F103RB GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.2
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_CL,PRINTF
  c include: ..\..\GD32F10x_Firmware_Library\Firmware\GD32F10x_standard_peripheral\Include;..\..\GD32F10x_Firmware_Library\Template;..\..\GD32F10x_Firmware_Library\Firmware\CMSIS;..\..\GD32F10x_Firmware_Library\Utilities;..\..\GD32F10x_Firmware_Library\Firmware\CMSIS\GD\GD32F10x\Source\ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application
    ../: main.c FLASH.c gd32f10x_it.c command.c
  group Peripherals
    ../../GD32F10x_Firmware_Library/Firmware/GD32F10x_standard_peripheral/Source/: gd32f10x_crc.c gd32f10x_dma.c gd32f10x_fmc.c gd32f10x_gpio.c gd32f10x_misc.c gd32f10x_rcu.c gd32f10x_usart.c
  group Doc
    ../: readme.txt
target GD32F10X_MD (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F103RB GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.2
  cpu: as above
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_MD,PRINTF
  c include: ..\..\GD32F10x_Firmware_Library\Firmware\GD32F10x_standard_peripheral\Include;..\..\GD32F10x_Firmware_Library\Template;..\..\GD32F10x_Firmware_Library\Utilities;..\..\GD32F10x_Firmware_Library\Firmware\CMSIS;..\..\GD32F10x_Firmware_Library\Firmware\CMSIS\GD\GD32F10x\Source\ARM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
target GD32F10X_HD (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F103RB GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.2
  cpu: as above
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_MD,PRINTF
  c include: ..\..\GD32F10x_Firmware_Library\Firmware\GD32F10x_standard_peripheral\Include;..\..\GD32F10x_Firmware_Library\Utilities;..\..\GD32F10x_Firmware_Library\Firmware\CMSIS;..\..\GD32F10x_Firmware_Library\Firmware\CMSIS\GD\GD32F10x\Source\ARM;..\
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x5000
target GD32F10X_XD (ARM-ADS)
  device: GD32F103ZE GigaDevice
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x08000000-0x0807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F10X_XD,PRINTF
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
software components: Device:Startup 2.0.0
