# Keil uVision project gd32f103rx.uvprojx, settings and files
target gd32f103rx (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F103RB GigaDevice
  pack: GigaDevice.GD32F10x_DFP.2.0.2
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00020000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Project
  AfterMake: fromelf --bin --output .\Objects\Project.bin .\Objects\Project.axf
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F10X_MD
  c include: ..\INC;..\USER;..\DFP_INC
  library: MicroLIB
  memory RVCT4: ROM 0x8002800 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group App
    ../USER/: App.c FLASH.c command.c
  group Global
    ../USER/: global.c gd32f10x_it.c systick.c
  group Inlcude
    ../INC/: global.h gd32f10x_libopt.h systick.h gd32f10x_it.h
  group Bsp
    ../USER/: bsp_usart.c bsp_adc.c bsp_i2c.c bsp_DMA.c Bsp_timer.c
  group Drv
    ../USER/: Drv_dsp_reset.c Drv_led.c Drv_ds18b20.c drv_power_down.c drv_vpx.c Drv_fpga.c
software components: CMSIS:CORE 5.4.0, Device:EVAL:GD32F103C 2.0.1, Device:GD32F10x_StdPeripherals:ADC 2.0.1, Device:GD32F10x_StdPeripherals:CRC 2.0.1, Device:GD32F10x_StdPeripherals:DMA 2.0.1, Device:GD32F10x_StdPeripherals:EXTI 2.0.1, Device:GD32F10x_StdPeripherals:FMC 2.0.1, Device:GD32F10x_StdPeripherals:GPIO 2.0.1, Device:GD32F10x_StdPeripherals:I2C 2.0.1, Device:GD32F10x_StdPeripherals:MISC 2.0.1, Device:GD32F10x_StdPeripherals:PMU 2.0.1, Device:GD32F10x_StdPeripherals:RCU 2.0.1, Device:GD32F10x_StdPeripherals:TIMER 2.0.1, Device:GD32F10x_StdPeripherals:USART 2.0.1, Device:GD32F10x_libopt 2.0.1, Device:Startup 2.0.1
